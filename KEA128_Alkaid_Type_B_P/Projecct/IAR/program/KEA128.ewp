# IAR project KEA128.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: KEAZ128xxx4 NXP KEAZ128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\Peripheral; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\FatFs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KEA128.hex
  ILINK.IlinkOutputFile: KEA128.out
  ILINK.IlinkIcfFile: KEA128.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drives/inc
    ../../../Libraries/drives/inc/: common.h KEA128_adc.h KEA128_flash.h KEA128_ftm.h KEA128_gpio.h KEA128_i2c.h KEA128_irq.h KEA128_kbi.h KEA128_pit.h KEA128_port.h KEA128_port_cfg.h KEA128_rtc.h KEA128_spi.h KEA128_systick.h misc.h uart.h
  group drives/src
    ../../../Libraries/drives/src/: common.c KEA128_adc.c KEA128_flash.c KEA128_ftm.c KEA128_gpio.c KEA128_i2c.c KEA128_irq.c KEA128_kbi.c KEA128_pit.c KEA128_port.c KEA128_rtc.c KEA128_spi.c KEA128_systick.c misc.c uart.c
  group FatFs
    ../../../Libraries/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Peripheral
    ../../../Libraries/Peripheral/: Peripheral_FUN.c Peripheral_FUN.h Peripheral_IIC.c Peripheral_IIC.h Peripheral_MPU6050.c Peripheral_MPU6050.h Peripheral_OLED.c Peripheral_OLED.h SD.c SD.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_SKEAZ1284.s
    ../../../Libraries/startup/DeviceSupport/: system_SKEAZ1284.c
  group user_c
    ../../USER/src/: Detection.c Interactive.c isr.c Kalman.c main.c MathTable.c Motor.c Speed.c Stand.c Steer.c
    ../../../Libraries/: version.txt
  group user_h
    ../../USER/inc/: Detection.h Interactive.h isr.h Kalman.h MathTable.h Motor.h Speed.h Stand.h Steer.h
    ../../../Libraries/drives/inc/: headfile.h
